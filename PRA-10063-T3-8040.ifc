Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2022-06-24T13:27:21
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: PRA-10063-T3-8040
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: PRA-10063-T3-8040; Light output ratio: 1; Luminous flux: 630 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 630 lm; LightEmitterNominalPower: 6 W; Spectrum: 380: 12934, 385: 1155, 390: 11614, 395: 10494, 400: 10484, 405: 10279, 410: 968, 415: 11352, 420: 17493, 425: 49381, 430: 110001, 435: 213323, 440: 422394, 445: 673726, 450: 939462, 455: 97829, 460: 851938, 465: 670014, 470: 549521, 475: 442322, 480: 39367, 485: 37832, 490: 392506, 495: 423255, 500: 468951, 505: 509823, 510: 551923, 515: 57673, 520: 59894, 525: 611155, 530: 623829, 535: 629598, 540: 636475, 545: 645361, 550: 655589, 555: 671682, 560: 690295, 565: 709359, 570: 730587, 575: 748998, 580: 767832, 585: 786295, 590: 801043, 595: 812518, 600: 821303, 605: 827334, 610: 827494, 615: 819016, 616: 814072, 617: 810179, 618: 806287, 619: 802012, 620: 797737, 625: 764787, 630: 724964, 635: 680899, 640: 638133, 645: 594845, 650: 555125, 655: 51894, 660: 486181, 665: 454614, 670: 422297, 675: 388355, 680: 352992, 685: 318193, 690: 282697, 695: 245701, 700: 215906, 705: 189853, 710: 163229, 715: 14476, 720: 12737, 725: 114158, 730: 97674, 735: 85444, 740: 75708, 745: 68751, 750: 61453, 755: 56451, 760: 52251; ColorTemperature: 4000 K; ColorRenderingIndex: 80

# IfcFlowTerminal: PRAGUE 7 Bollard
In: Default Building
Type - Description: - Lamp LED - CRI Ra > 80 - MacAdam Ellipse 3 SDCM - Colour 3000K , 4000K - Die-cast aluminium housing - Extruded aluminium column - Pre-treated before powder coating ensuring high corrosion resistance - Stainless steel fasteners in grade 304 with zinc flake coating (ZFC) - Durable silicone rubber gasket - Clear toughened glass - High-efficiency PMMA lens - Integral control gear - Solar panel mono-crystalline silicon high-efficiency 4x10W - Lithium Iron Phosphate (LiFePO4 ) battery 16.5Ah 12Vdc - Solar charger controller system 12V 10A - Different dimming options are available: ND: Dusk to Dawn, CT: Custom (5 Step dimming, Custom hours, Custom dimming levels) - Maximum 15 hours of operation time (100%) - Without any sun (Autonomy), the battery would last for maximum 5 days - Full automatic electronic protection function against short circuit, overcurrent, overload, overvoltage and high temperature - Luminaires operation time depends on the weather conditions - Remote solar charge controller can be ordered as an accessory - Standard: Off-grid, 100% solar, not connected to the utility grid. Utility grid connection is available upon request - Autonomy and Operation time calculations are done with the following information: Peak SunHour (PSH) is 3 hours. Hours of operation is 12 hours per day; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: PRAGUE, Bollards; Housing color: Not specified
General Information - Article number: PRA-10063-T3-8040; Article name: PRAGUE 7 Bollard; Weight: 5.7 kg; Case length: 17.5 cm; Case width: 20 cm; Case height: 50 cm; Uld creation date: 24.06.2022 11:27:21
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 6 W
Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 6 W; LightFixtureMountingType: Standing; LightFixturePlacingType: Floor; ManufacturersSpecificInformation: LIGMAN
